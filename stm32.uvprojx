# Keil uVision project stm32.uvprojx, settings and files
target GPIO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\Source\FWLib\inc;.\Source\FWLib\src;.\Source\Startup;.\Source;..\【A】LED循环闪动;..\stm32密码锁;.\Source;.\Source;..\daima
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Source/Startup/: cortexm3_macro.s stm32f10x_vector.s
  group User
    ./Source/: stm32f10x_it.c
    ./: main.c
  group FWLib
    ./Source/FWLib/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_systick.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_exti.c
  group IAP
    ./: stmflash.c stmflash.h
software components: CMSIS:CORE 5.0.1
